File: hardware/untitled.kicad_sch (KiCad schematic)
At the start: 16 parts, among them U3 LM3940

Commit message: Layout done
Parts:
- D5: footprint Diode_SMD:D_MELF -> Diode_SMD:D_SOD-123
